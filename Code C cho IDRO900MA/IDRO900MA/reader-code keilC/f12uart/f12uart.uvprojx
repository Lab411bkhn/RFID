# Keil uVision project f12uart.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: f12uart +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: E:\PROJECT\STM32\LIB\CMSIS;.\RTE\Device\STM32F103C8;E:\PROJECT\STM32\LIB\CMSIS\CM3\CoreSupport;E:\PROJECT\STM32\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;E:\PROJECT\STM32\LIB\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c user.c delay.c stm32f10x_it.c
  group Include
    ./: main.h delay.h stm32f10x_it.h
    ../../../ControllerReader/stsw-stm32054/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_rcc.h
    ../../../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c
  group ::Device
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s stm32f10x_conf.h system_stm32f10x.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.4/Device/StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.4/RTE_Driver/: GPIO_STM32F10x.c
software components: CMSIS:CORE 3.20.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.0, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
